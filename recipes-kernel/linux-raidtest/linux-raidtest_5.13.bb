#
# Copyright (c) Roberto A. Foglietta
#
# Authors:
#  Roberto A. Foglietta <roberto.foglietta@gmail.com>
#
# SPDX-License-Identifier: MIT
#

require linux-raidtest.inc

SRC_URI[sha256sum] += "9ce4c15b10d4dc9e353f3105dd11b9d2d2ef83e24772d68d3cf0830fe5f527a1"

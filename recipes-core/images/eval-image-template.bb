#
# Copyright (c) Siemens AG, 2022
# Copyright (c) Roberto A. Foglietta, 2023
#
# Authors:
#  Jan Kiszka <jan.kiszka@siemens.com>
#  Roberto A. Foglietta <roberto.foglietta@gmail.com>
#
# SPDX-License-Identifier: MIT
#

require eval-image-template.inc

DESCRIPTION = "${DESCHEAD} template"

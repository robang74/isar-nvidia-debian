#
# Copyright (c) Roberto A. Foglietta
#
# Authors:
#  Roberto A. Foglietta <roberto.foglietta@gmail.com>
#
# SPDX-License-Identifier: MIT
#

require linux-raidtest.inc

SRC_URI[sha256sum] = "11614fc737638f693d02bf0d95422dfe2b3bcf3088196cd1c4c799cfdf675b70"
